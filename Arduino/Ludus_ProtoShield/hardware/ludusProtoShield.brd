# Repository MDSRoboticsTeam/STEM

File README.md:

# STEM
STEM Robotics and Electronics

## Repository contents

* /Arduino - Arduino lessons and other interesting stuff 
* /Robotics - Content specifically related to robotics (e.g. information on building a robot)

## EAGLE design Arduino/Ludus_ProtoShield/hardware/ludusProtoShield.brd

File Arduino/Readme.md:

# Collection of Arduino artifacts

## Contents

* /Lessons - Class lessons and mini-projects

* /Ludus_Proshield - Motor driver example code 

## Links

* [Arduino Homepage](http://www.arduino.cc)
* [Arduino Classes](http://polygondoor.com.au/creating-classes-in-c-for-arduino/)

Board: 2 copper layers, 59.7 x 53.3 mm, 65 parts (16 on the bottom side), 42 nets.

Parts:
C1, C2: 0.1uF; 0603-CAP
C4: 10uf , 20V; EIA3528
F1, F2: PTC-1206
FID1, FID2: FIDUCIAL1X2; FIDUCIAL-1X2
FRAME2: FRAME-LEDGER; CREATIVE_COMMONS
JP0: D0; 1X03_LOCK
JP1: D1; 1X03_LOCK
JP2: D2; 1X03_LOCK
JP3: D3; 1X03_LOCK
JP4: D4; 1X03_LOCK
JP5: D5; 1X03_LOCK
JP6: D6; 1X03_LOCK
JP7: D7; 1X03_LOCK
JP8: D8; 1X03_LOCK
JP9: D9; 1X03_LOCK
JP10: D10; 1X03_LOCK
JP11: D11; 1X03_LOCK
JP12: D12; 1X03_LOCK
JP13: D13; 1X03_LOCK
JP14: A0; 1X03_LOCK
JP15: A1; 1X03_LOCK
JP16: A2; 1X03_LOCK
JP17: A3; 1X03_LOCK
JP18: A4; 1X03_LOCK
JP19: A5; 1X03_LOCK
JP20, JP21: 1X04
JP22, JP23: 1X04_LOCK
LED1, LED2: Yellow; LED-0603
LED3, LED4, LED5: BLUE; LED-0603
LOGO1: OSHW-LOGOM; OSHW-LOGO-M
LOGO2, LOGO4: SFE_LOGO_NAME_FLAME.1_INCH; SFE_LOGO_NAME_FLAME_.1
LOGO3: SFE_LOGO_FLAME.2COP; SFE_LOGO_FLAME_COPPER_.2
R1, R2, R3, R4: 1K; 0603-RES
R5: 330; 0603-RES
S1, S2: AYZ0202
S4: RESET; TACTILE-SWITCH-SMD
SJ3, SJ4: PAD-JUMPER-3-3OF3_NC_BY_TRACE_YES_SILK_FULL_BOX
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11: PAD.03X.05
U1: ARDUINO; UNO_R3_SHIELD_NOLABELS_LOCK
U2: TB6612FNG; SSOP24
U$1: SFE_LUDUSSFE_LUDUS-M; SFE_LUDUS-M

Connections:
3.3V: JP20.2, JP22.2, U1.3.3V
A0: JP14.3, U1.A0
A1: JP15.3, U1.A1
A2: JP16.3, U1.A2
A3: JP17.3, U1.A3
A4: JP18.3, SJ3.3, U1.A4
A5: JP19.3, SJ4.3, U1.A5
AIN1: JP4.3, TP1.P$1, U1.D4, U2.21
AIN2: JP5.3, TP2.P$1, U1.D5, U2.22
ANALOG_PWR_RAIL: JP14.2, JP15.2, JP16.2, JP17.2, JP18.2, JP19.2, S1.2
AOUT1: JP21.4, JP23.4, R1.2, R2.2, U2.1, U2.2
AOUT2: JP21.3, JP23.3, LED1.C, LED3.A, U2.5, U2.6
BIN1: JP7.3, TP4.P$1, U1.D7, U2.17
BIN2: JP8.3, TP5.P$1, U1.D8, U2.16
BOUT1: JP21.2, JP23.2, R3.2, R4.2, U2.11, U2.12
BOUT2: JP21.1, JP23.1, LED2.C, LED4.A, U2.7, U2.8
D0: JP0.3, U1.RX
D1: JP1.3, U1.TX
D2: JP2.3, U1.D2
D9: JP9.3, U1.D9
D10: JP10.3, U1.D10
D11: JP11.3, U1.D11
D12: JP12.3, U1.D12
D13: JP13.3, LED5.A, TP7.P$1, U1.D13
FUSED_VCC: C2.1, F2.2, S1.3, S2.3, U2.19, U2.20
FUSED_VIN: C1.1, C4.A, F1.2, S1.1, S2.1, U2.13, U2.14, U2.24
GND: C1.2, C2.2, C4.C, JP0.1, JP1.1, JP2.1, JP3.1, JP4.1, JP5.1, JP6.1, JP7.1, JP8.1, JP9.1, JP10.1, JP11.1, JP12.1, JP13.1, JP14.1, JP15.1, JP16.1, JP17.1, JP18.1, JP19.1, JP20.1, JP22.1, R5.1, S4.1, S4.2, TP11.P$1, U1.GND@0, U1.GND@1, U1.GND@2, U2.3, U2.4, U2.9, U2.10, U2.18
unnamed: LED5.C, R5.2
unnamed: LED1.A, R1.1
unnamed: LED3.C, R2.1
unnamed: LED2.A, R3.1
unnamed: LED4.C, R4.1
PWMA: JP3.3, TP3.P$1, U1.D3, U2.23
PWMB: JP6.3, TP6.P$1, U1.D6, U2.15
PWR_RAIL: JP0.2, JP1.2, JP2.2, JP3.2, JP4.2, JP5.2, JP6.2, JP7.2, JP8.2, JP9.2, JP10.2, JP11.2, JP12.2, JP13.2, S2.2
RESET: S4.3, S4.4, TP8.P$1, U1.RES
SCL: SJ4.1, U1.SCL
SCL_I2C_PORT: JP20.4, JP22.4, SJ4.2
SDA: SJ3.1, U1.SDA
SDA_I2C_PORT: JP20.3, JP22.3, SJ3.2
VCC: F2.1, TP10.P$1, U1.5V
VIN: F1.1, TP9.P$1, U1.VIN

## Commit log

2018-02-24 Create BlinkFade
2018-02-24 Initial commit
    Blink a single LED
2018-02-24 Add curved power wires
2018-02-25 Schematic clean-up and add simple switch
2018-02-25 Modified to use serial plotter
2018-02-26 Update Readme.md
    Add description of Blink, PWM, Dim projects
2018-03-03 Updated Blink and Dim
2018-03-03 Add Ludus Protoshield
    From Sparkfun downloaded zip
2018-03-03 Change name of Ludus directory
    REmoved -master
2018-03-07 Add Hello_Ludus
    File to test Ludus driver board
2018-03-10 Add Basic Encoder test code
2018-03-10 Modify to run and stop
2018-03-10 Modify to turn 360 deg
    Tweak code to have motors move 360 deg
2018-03-12 Add code for dual motor encoders
2018-03-12 Add low level interrupt code for pin 9
2018-03-13 Fix dual interrupts using Ext D2 and A0
    Rates are not equal?
2018-03-13 Update pulses and pulse rate
    Pulse rate is noisy, need to add rate for both motors
2018-03-14 Updated comments
    No functional changes (In theory)
2018-03-15 Add instrumentation for 2nd motor rate
2018-03-19 Add Cavmotor class
    Constructor and basic movement methods added - clean compile
2018-03-20 Add class ISR code
    Added commented sample code to attach ISR inside Cavmotor Class
2018-03-22 Add classIrq.cpp
    Compile troubles, probably need to integrate classIrq functionality into
    Cavmotor rather than a separate class.
2021-10-02 Create img
2021-10-02 Create tmp
2021-10-04 Add files via upload
    Dim internal and External LED when pushbutton is selected
2021-10-05 Create LEDSpec
2021-10-05 Add files via upload
    LED Spec Sheet
2021-10-08 Rename LED.md to LED Current Limiting.md
2021-10-27 Add files via upload
    Light Dependent Resistor Demo Code

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
SparkFun-Aesthetics: Released under the Creative Commons Attribution Share-Alike 4.0 License
SparkFun-Aesthetics: https://creativecommons.org/licenses/by-sa/4.0
